options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cutoff
  id: variable
  parameters:
    value: 100k
  states: {}
- name: freq
  id: variable
  parameters:
    value: '92.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2M
  states: {}
- name: transition
  id: variable
  parameters:
    value: 1M
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 500k
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '48'
    taps: ''
    type: ccf
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
